* D:\YandexDisk\KiCad Projects\timr_canon\timer.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 22.09.2018 23:10:52

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  3.3V Net-_C3-Pad1_ Net-_C4-Pad1_ Net-_SW2-Pad2_ 3.3V Net-_R1-Pad2_ Net-_R2-Pad2_ ? ? ? ENC_B ENC_1 ENC_2 ? ? GND 3.3V ? I2C_SCL I2C_SDA LED_1 LED_2 SWDIO SWCLK ? ? ? ? ? ? GND GND STM32F030K6Tx
J2  GND I2C_SDA I2C_SCL 3.3V CONN_01X04
Y1  Net-_C4-Pad1_ Net-_C3-Pad1_ Crystal
C3  Net-_C3-Pad1_ GND 20pF
C4  Net-_C4-Pad1_ GND 20pF
U2  Net-_R1-Pad1_ GND ? GNDA Net-_J1-Pad1_ ? 4N25
U4  Net-_R2-Pad1_ GND ? GNDA Net-_J1-Pad2_ ? 4N25
R1  Net-_R1-Pad1_ Net-_R1-Pad2_ 470
R2  Net-_R2-Pad1_ Net-_R2-Pad2_ 470
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ GNDA CONN_01X03
C2  3.3V GND 22uF
U1  GND 3.3V Vbat AMS1117-3.3
C1  Vbat GND 10uF
U5  Net-_R3-Pad2_ GND Vbat 5V Net-_R4-Pad1_ MCP73831-2-OT
J3  5V ? ? ? GND GND USB_OTG
R4  Net-_R4-Pad1_ GND 2k
D1  Net-_D1-Pad1_ 5V LED
R3  Net-_D1-Pad1_ Net-_R3-Pad2_ 200
C5  5V GND 4.7uF
J4  3.3V SWDIO SWCLK GND CONN_01X04
J5  Vbat GND CONN_01X02
SW1  ENC_1 GND ENC_2 3.3V ENC_B Encoder
C7  ENC_2 GND 100nF
C6  ENC_1 GND 100nF
R5  3.3V ENC_1 4.7k
R6  3.3V ENC_2 4.7k
R7  ENC_B GND 4.7k
C8  ENC_B GND 100nF
SW2  GND Net-_SW2-Pad2_ SW_Push
D3  GND Net-_D3-Pad2_ LED
R9  Net-_D3-Pad2_ LED_2 470
R8  Net-_D2-Pad2_ LED_1 470
D2  GND Net-_D2-Pad2_ LED
R10  3.3V I2C_SCL 4k7
R11  3.3V I2C_SDA 4k7

.end
